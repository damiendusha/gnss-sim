options:
  parameters:
    author: Damien Dusha
    generate_options: qt_gui
    id: gnss_sim_playback_10MHz
    output_language: python
    title: GPS Simulator Playback - 10Msps
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 1575.42e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {}
- name: gps_gain
  id: variable_qtgui_range
  parameters:
    label: gps_gain
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sigma_awgn
  id: variable_qtgui_range
  parameters:
    label: sigma_awgn
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '10'
    value: '1.0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: sigma_awgn
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/damien/bitbucket/gnss-sim/gpssim.bin
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0 / (2**12)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gps_gain
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_source0: external
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
